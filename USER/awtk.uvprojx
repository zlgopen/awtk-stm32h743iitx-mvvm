# Keil uVision project awtk.uvprojx, settings and files
target awtkapp (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4,HAS_AWTK_CONFIG
  c misc: --gnu
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\USMART;..\MALLOC;..\HARDWARE\TOUCH;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\MPU;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\PCF8574;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\source;..\awtk\src\ext_widgets;..\awtk;..\awtk\src;..\awtk\3rd;..\awtk\3rd\nanovg\base;..\awtk\3rd\nanovg;..\awtk\3rd\agge;..\awtk\3rd\libunibreak;..\awtk-port;.\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\spi;.\APP\nrf24l01;.\APP\dht11;.\APP\oled;.\APP\RC522;.\APP\Tetris;.\APP\ball;.\APP\touch;.\APP\snake;.\awtk\3rd;.\awtk\src;.\awtk-port;..\TencentOS\arch\arm\arm-v7m\common\include;..\TencentOS\arch\arm\arm-v7m\cortex-m7\armcc;..\TencentOS\kernel\core\include;..\TencentOS\kernel\hal\include;..\TencentOS\kernel\pm\include;..\TencentOS\TOS-CONFIG;..\awtk-sqlite3\src;..\awtk\3rd\gpinyin\include,..\awtk-mvvm\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_nand.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/NAND/: ftl.c nand.c nandtester.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c touch.c ott2001a.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group README
    ../: readme.txt
  group awtk
    ../awtk/3rd/agge/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
    ../awtk/3rd/libunibreak/: emojidef.c graphemebreak.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c
    ../awtk/3rd/nanovg/agge/: nanovg_agge.cpp nanovg_vertex.cpp
    ../awtk/3rd/nanovg/base/: nanovg.c
    ../awtk/src/: awtk_global.c
    ../awtk/src/base/: asset_loader.c asset_loader_default.c assets_manager.c bitmap.c canvas.c children_layouter.c children_layouter_factory.c clip_board.c date_time_format.c dialog.c dialog_highlighter.c dialog_highlighter_factory.c enums.c event_queue.c events.c font.c font_loader.c font_manager.c glyph_cache.c graphic_buffer.c hscrollable.c idle.c image_base.c image_loader.c image_manager.c input_device_status.c input_engine.c input_method.c layout.c lcd.c lcd_profile.c line_break.c locale_info.c main_loop.c native_window.c self_layouter.c self_layouter_factory.c shortcut.c style.c style_const.c style_factory.c style_mutable.c suggest_words.c system_info.c text_edit.c theme.c timer.c ui_builder.c ui_feedback.c ui_loader.c velocity.c vgcanvas.c widget.c widget_animator.c widget_animator_factory_null.c widget_animator_manager.c widget_factory.c widget_vtable.c window.c window_animator.c window_animator_factory.c window_base.c window_manager.c data_reader_asset.c
    ../awtk/src/blend/: blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgb565.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgr888.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgb565.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgb565.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgb565.c blend_image_rgb565_rgba8888.c blend_image_rgb888_bgr565.c blend_image_rgb888_bgra8888.c blend_image_rgb888_rgb565.c blend_image_rgb888_rgb888.c blend_image_rgb888_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgb565.c blend_image_rgba8888_rgba8888.c fill_image_abgr8888.c fill_image_argb8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgb888.c fill_image_rgba8888.c image_g2d.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgb888.c rotate_image_rgba8888.c soft_g2d.c stm32_g2d.c
    ../awtk/src/clip_board/: clip_board_default.c
    ../awtk/src/dialog_highlighters/: dialog_highlighter_builtins.c dialog_highlighter_default.c
    ../awtk/src/ext_widgets/canvas_widget/: canvas_widget.c
    ../awtk/src/ext_widgets/color_picker/: color_component.c color_picker.c rgb_and_hsv.c
    ../awtk/src/ext_widgets/combo_box_ex/: combo_box_ex.c
    ../awtk/src/ext_widgets/: ext_widgets.c
    ../awtk/src/ext_widgets/features/: draggable.c
    ../awtk/src/ext_widgets/file_browser/: file_browser.c file_browser_view.c file_chooser.c
    ../awtk/src/ext_widgets/gif_image/: gif_image.c
    ../awtk/src/ext_widgets/guage/: guage.c guage_pointer.c
    ../awtk/src/ext_widgets/image_animation/: image_animation.c
    ../awtk/src/ext_widgets/image_value/: image_value.c
    ../awtk/src/ext_widgets/keyboard/: candidates.c keyboard.c lang_indicator.c
    ../awtk/src/ext_widgets/mledit/: line_number.c mledit.c
    ../awtk/src/ext_widgets/mutable_image/: mutable_image.c
    ../awtk/src/ext_widgets/progress_circle/: progress_circle.c
    ../awtk/src/ext_widgets/rich_text/: rich_text.c rich_text_node.c rich_text_parser.c rich_text_render_node.c rich_text_view.c
    ../awtk/src/ext_widgets/scroll_label/: hscroll_label.c
    ../awtk/src/ext_widgets/scroll_view/: children_layouter_list_view.c list_item.c list_view.c list_view_h.c scroll_bar.c scroll_view.c
    ../awtk/src/ext_widgets/slide_menu/: slide_menu.c
    ../awtk/src/ext_widgets/slide_view/: slide_indicator.c slide_view.c
    ../awtk/src/ext_widgets/svg_image/: svg_image.c
    ../awtk/src/ext_widgets/switch/: switch.c
    ../awtk/src/ext_widgets/text_selector/: text_selector.c
    ../awtk/src/ext_widgets/time_clock/: time_clock.c
    ../awtk/src/font_loader/: font_loader_bitmap.c font_loader_stb.c
    ../awtk/src/graphic_buffer/: graphic_buffer_default.c
    ../awtk/src/image_loader/: image_loader_stb.c
    ../awtk/src/input_engines/: input_engine_null.c
    ../awtk/src/input_methods/: input_method_creator.c
    ../awtk/src/layouters/: children_layouter_builtins.c children_layouter_default.c children_layouter_parser.c self_layouter_builtins.c self_layouter_default.c self_layouter_menu.c self_layouter_parser.c
    ../awtk/src/lcd/: lcd_mem_bgr565.c lcd_mem_bgr888.c lcd_mem_bgra8888.c lcd_mem_rgb565.c lcd_mem_rgba8888.c
    ../awtk/src/main_loop/: main_loop_simple.c
    ../awtk/src/misc/: new.cpp
    ../awtk/src/native_window/: native_window_raw.c
    ../awtk/src/platforms/raw/: cond_var_null.c
    ../awtk/src/svg/: bsvg.c bsvg_builder.c bsvg_draw.c bsvg_to_svg.c svg_path.c svg_path_parser.c svg_shape.c svg_to_bsvg.c
    ../awtk/src/tkc/: asset_info.c buffer.c color.c color_parser.c compressor.c crc.c darray.c data_reader.c data_reader_factory.c data_reader_file.c data_writer.c data_writer_factory.c data_writer_file.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c expr_eval.c fs.c func_call_parser.c idle_info.c idle_manager.c int_str.c iostream.c istream.c log.c matrix.c mem.c mutex_nest.c named_value.c object.c object_array.c object_default.c object_locker.c ostream.c path.c rect.c ring_buffer.c rom_fs.c slist.c socket_pair.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c utf8.c utils.c value.c value_desc.c wstr.c
    ../awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
    ../awtk/src/vgcanvas/: vgcanvas_nanovg_soft.c
    ../awtk/src/widget_animators/: widget_animator_factory.c widget_animator_prop.c widget_animator_prop2.c widget_animator_scroll.c
    ../awtk/src/widgets/: app_bar.c button.c button_group.c calibration_win.c check_button.c clip_view.c color_tile.c column.c combo_box.c combo_box_item.c dialog_client.c dialog_helper.c dialog_title.c digit_clock.c dragger.c edit.c grid.c grid_item.c group_box.c image.c label.c overlay.c pages.c popup.c progress_bar.c row.c slider.c spin_box.c system_bar.c tab_button.c tab_button_group.c tab_control.c view.c widgets.c
    ../awtk/src/window_animators/: window_animator_builtins.c window_animator_center_scale.c window_animator_common.c window_animator_fade.c window_animator_htranslate.c window_animator_popdown.c window_animator_popup.c window_animator_slide.c window_animator_slide_down.c window_animator_slide_left.c window_animator_slide_right.c window_animator_slide_up.c window_animator_vtranslate.c
    ../awtk/src/window_manager/: window_manager_default.c
    ../awtk/src/xml/: xml_builder.c xml_parser.c
  group awtk-port
    ../awtk-port/: assert.c awtk_config.h lcd_impl.c main_loop_impl.c platform.c sys_tick.c
    ../awtk/src/platforms/tos/: mutex.c rtos.c semaphore.c thread.c
    ../awtk/src/platforms/common/: rtos.h sys_tick_handler.c
  group tecentos
    ../TencentOS/arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
    ../TencentOS/arch/arm/arm-v7m/cortex-m7/armcc/: port_c.c port.h port_config.h port_s.S
    ../TencentOS/kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_rwlock.c tos_stopwatch.c
    ../TencentOS/kernel/pm/: tos_pm.c tos_tickless.c
    ../TencentOS/TOS-CONFIG/: tos_config.h
  group awtk-fs
    ../awtk-fs-adapter/src/: fs_os_fatfs.c
  group sqlite3
    ../awtk-sqlite3/src/: sqlite3.c
    ../awtk-sqlite3/demos/: sqlite3_test.c
  group gpinyin
    ../awtk/3rd/gpinyin/src/: dictlist.cpp dicttrie.cpp lpicache.cpp matrixsearch.cpp mystdlib.cpp ngram.cpp pinyinime.cpp searchutility.cpp spellingtrie.cpp splparser.cpp utf16char.cpp
    ../awtk/src/input_engines/: input_engine_pinyin.cpp
  group conf-io
    ../awtk/src/conf_io/: app_conf.c app_conf_init.c app_conf_init_ini.c app_conf_init_json.c app_conf_init_ubjson.c conf_ini.c conf_json.c conf_node.c conf_obj.c conf_ubjson.c
  group ubjson
    ../awtk/src/ubjson/: ubjson_parser.c ubjson_reader.c ubjson_writer.c
  group mvvm
    ../awtk-mvvm/src/mvvm/awtk/: binding_context_awtk.c mvvm_awtk.c navigator_handler_awtk.c widget_hardware.c
    ../awtk-mvvm/src/mvvm/base/: binding_context.c binding_rule_parser.c command_binding.c data_binding.c mvvm_base.c navigator.c navigator_handler.c navigator_request.c utils.c value_converter.c value_converter_delegate.c value_validator.c value_validator_delegate.c view_model.c view_model_app_conf.c view_model_array.c view_model_array_dummy.c view_model_array_object_wrapper.c view_model_compositor.c view_model_dummy.c view_model_factory.c view_model_object_wrapper.c
    ../awtk-mvvm/src/mvvm/hardware/: device_factory.c
    ../awtk-mvvm/src/mvvm/: mvvm.c
  group awtk-app
    ../awtk-mvvm/demos/demo21/: application.c
